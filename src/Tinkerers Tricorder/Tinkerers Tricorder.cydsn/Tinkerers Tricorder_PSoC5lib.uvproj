# Keil uVision project Tinkerers Tricorder_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP032 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: Tinkerers Tricorder_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h IDrive.c IDrive.h IDrive_PM.c Measure_Mux.c Measure_Mux.h TIA.c TIA.h TIA_PM.c Clipping_Sense.c Clipping_Sense.h Clipping_Sense_PM.c Status_Reg.c Status_Reg.h Phase.c Phase.h Drive.c Drive.h Drive_PM.c Divider.c Divider.h Divider_PM.c Sine_DMA_dma.c Sine_DMA_dma.h SOC_Go.c SOC_Go.h ADC_Clock_Ext.c ADC_Clock_Ext.h ADC.c ADC.h ADC_PM.c ADC_INT.c ADC_Bypass_P32_aliases.h ADC_Bypass_P32.c ADC_Bypass_P32.h ADC_Ext_CP_Clk.c ADC_Ext_CP_Clk.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h Drive_Sense_aliases.h Drive_Sense.c Drive_Sense.h TIA_Output_aliases.h TIA_Output.c TIA_Output.h Drive_In_aliases.h Drive_In.c Drive_In.h TIA_Sense_aliases.h TIA_Sense.c TIA_Sense.h drive_range_aliases.h drive_range.c drive_range.h drive_freq_range_aliases.h drive_freq_range.c drive_freq_range.h tia_range_aliases.h tia_range.c tia_range.h LCD_LCD.h LCD_LCD.c ResistiveTouch_1.c ResistiveTouch_1_PM.c ResistiveTouch_1.h ResistiveTouch_1_AMux.c ResistiveTouch_1_AMux.h ResistiveTouch_1_xm_aliases.h ResistiveTouch_1_xm.c ResistiveTouch_1_xm.h ResistiveTouch_1_xp_aliases.h ResistiveTouch_1_xp.c ResistiveTouch_1_xp.h ResistiveTouch_1_ym_aliases.h ResistiveTouch_1_ym.c ResistiveTouch_1_ym.h ResistiveTouch_1_yp_aliases.h ResistiveTouch_1_yp.c ResistiveTouch_1_yp.h ResistiveTouch_1_ADC_SAR.c ResistiveTouch_1_ADC_SAR.h ResistiveTouch_1_ADC_SAR_INT.c ResistiveTouch_1_ADC_SAR_PM.c ResistiveTouch_1_ADC_SAR_IRQ.c ResistiveTouch_1_ADC_SAR_IRQ.h ResistiveTouch_1_ADC_SAR_theACLK.c ResistiveTouch_1_ADC_SAR_theACLK.h Drive_Out_aliases.h Drive_Out.c Drive_Out.h lcd_d_c_aliases.h lcd_d_c.c lcd_d_c.h lcd_sclk_aliases.h lcd_sclk.c lcd_sclk.h lcd_mosi_aliases.h lcd_mosi.c lcd_mosi.h TIA_Input_aliases.h TIA_Input.c TIA_Input.h LCD_RST_aliases.h LCD_RST.c LCD_RST.h LCD_CS_aliases.h LCD_CS.c LCD_CS.h LCD_LCD_Control.c LCD_LCD_Control.h LCD_LCD_SPI.c LCD_LCD_SPI.h LCD_LCD_SPI_PM.c LCD_LCD_SPI_INT.c LCD_LCD_SPI_PVT.h LCD_LCD_SPI_IntClock.c LCD_LCD_SPI_IntClock.h LCD_glcdfont.c LCD_glcdfont.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP032 Cypress
  cpu: as above
  output: Tinkerers Tricorder_PSoC5lib (library)
